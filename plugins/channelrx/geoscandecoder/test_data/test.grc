options:
  parameters:
    generate_options: qt_gui
    id: geoscan_sdr_test
    output_language: python
    run_options: run
    title: geoscan_sdr_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 9600*4
  states: {}
- name: alt
  id: parameter
  parameters:
    label: Station Alt
    type: str
    value: '100'
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*625/4/3
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: tx_comps
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*625/4/3
    showports: 'True'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/e.meltsov@geoscan.lan/Desktop/test_mod_demod_output.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/e.meltsov@geoscan.lan/Desktop/test_framer_output.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/e.meltsov@geoscan.lan/Desktop/test_mod_demod_deframer_output.bin
    type: byte
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_1_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_length+2
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 2e6
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/e.meltsov@geoscan.lan/Desktop/test_IQ_GEOSCAN_SAT_03NOISE_NODRIFT_2MSPS_CS16.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.3'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: device
  id: parameter
  parameters:
    label: device
    type: str
    value: serial=H1CHT2Y
  states: {}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '8'
    mask: '0x21'
    reset_tag_key: '"packet_len"'
    seed: '0x1FF'
  states: {state: disabled}
- name: digital_crc_check_0_0
  id: digital_crc_check
  parameters:
    discard_crc: '1'
    final_xor: '0x0'
    initial_value: '0xFFFF'
    input_reflected: '0'
    num_bits: '16'
    poly: '0x8005'
    result_reflected: '0'
    swap_endianness: '0'
  states: {state: disabled}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: math.pi/4
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '4'
    sensitivity: math.pi/4
  states: {state: disabled}
- name: doppler_invert_rx
  id: parameter
  parameters:
    label: Invert Doppler compensation RX (0/2)
    type: intx
    value: '0'
  states: {}
- name: doppler_invert_tx
  id: parameter
  parameters:
    label: Invert Doppler compensation TX (1/2)
    type: intx
    value: '1'
  states: {}
- name: frame_length
  id: parameter
  parameters:
    label: Frame Length (64 or 72)
    type: intx
    value: '72'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lat
  id: parameter
  parameters:
    label: Station Lat
    type: str
    value: '59.0208'
  states: {}
- name: lon
  id: parameter
  parameters:
    label: Station Lon
    type: str
    value: '30.3750'
  states: {}
- name: pdu_pdu_to_stream_x_0_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_1_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: period
  id: parameter
  parameters:
    label: Doppler update period (ms)
    type: intx
    value: '50'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '625'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    interp: '12'
    type: ccc
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    label: Center frequency
    type: intx
    value: '436000000'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: RX Gain [0 - 76]
    type: intx
    value: '20'
  states: {}
- name: sat
  id: parameter
  parameters:
    label: sat
    type: str
    value: STRATOSAT
  states: {}
- name: skm_geoscan_framer_0
  id: skm_geoscan_framer
  parameters:
    data_packet_size: frame_length
  states: {state: disabled}
- name: skm_simple_deframer_0_0
  id: skm_simple_deframer
  parameters:
    frame_length_bits: int((frame_length+2)*8)
    syncword: '"0x930B51DE"'
    syncword_bit_length: '32'
    thresold: '6'
  states: {state: disabled}
- name: tle
  id: parameter
  parameters:
    type: str
    value: /home/user/Desktop/Orbitron/Tle/active.txt
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX Gain [0 - 89]
    type: intx
    value: '30'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: rx_freq-200e3
    dev_addr: device
    gain0: tx_gain
    samp_rate: 2e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_freq-200e3
    dev_addr: device
    gain0: rx_gain
    samp_rate: 2e6
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: zmq_addr_tx
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zmq_addr_rx
  id: parameter
  parameters:
    label: ZeroMQ addr RX (SKM <- RADIO)
    type: str
    value: tcp://127.0.0.1:5556
  states: {}
- name: zmq_addr_tx
  id: parameter
  parameters:
    label: ZeroMQ addr TX (SKM -> RADIO)
    type: str
    value: tcp://127.0.0.1:5555
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_1_0_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_1_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_1_0_0_0, '0', channels_channel_model_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', skm_simple_deframer_0_0, '0']
- [blocks_stream_to_tagged_stream_1_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [blocks_throttle2_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [channels_channel_model_0, '0', uhd_usrp_sink_0, '0']
- [digital_additive_scrambler_bb_0_0, '0', pdu_tagged_stream_to_pdu_1_0, '0']
- [digital_crc_check_0_0, ok, pdu_pdu_to_stream_x_0_0, pdus]
- [digital_gfsk_demod_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [pdu_pdu_to_stream_x_0_0, '0', blocks_file_sink_0_1, '0']
- [pdu_tagged_stream_to_pdu_1_0, pdus, digital_crc_check_0_0, in]
- [rational_resampler_xxx_0, '0', blocks_divide_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_gfsk_demod_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_sink_x_0_0, '0']
- [skm_geoscan_framer_0, '0', blocks_file_sink_0_0, '0']
- [skm_geoscan_framer_0, '0', digital_gfsk_mod_0, '0']
- [skm_simple_deframer_0_0, '0', blocks_stream_to_tagged_stream_1_0, '0']
- [zeromq_sub_source_1, '0', skm_geoscan_framer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
